# Keil uVision project UART mode 1 truyen nhan 2 vxl.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: UART mode 1 truyen nhan 2 vxl +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c main.h port.h
    ../Library/: UART mode 1.c Delay.c LCD 16x2.c
