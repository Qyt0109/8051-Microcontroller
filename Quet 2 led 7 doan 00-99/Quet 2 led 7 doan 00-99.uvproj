# Keil uVision project Quet 2 led 7 doan 00-99.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Quet 2 led 7 doan 00-99 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c main.h
    ../Library/: Delay.c
