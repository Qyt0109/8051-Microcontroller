# Keil uVision project UART Mode 0 mo rong ngo ra.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: UART Mode 0 mo rong ngo ra +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c main.h port.h
    ../Library/: Delay.c UART mode 0 mo rong ngo vao dung IC 74165.c
