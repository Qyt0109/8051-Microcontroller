# Keil uVision project Giao tiep may tinh UART - RS 232.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Giao tiep may tinh UART - RS 232 +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: ru
  group Source Group 1
    ./: main.c main.h
    ../Library/: UART mode 1.c Delay.c
