# Keil uVision project Mo rong ngo ra dung IC 74HC595.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Mo rong ngo ra dung IC 74HC595 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c main.h port.h
    ../Library/: 74595.c Delay.c
