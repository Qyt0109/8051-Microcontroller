#include "main.h"
#include "..\Library\Delay.h"
#include "..\Library\74595.h"

unsigned char code Font5x7[][7]={0x0E, 0x11, 0x13, 0x15, 0x19, 0x11, 0x0E,		// 0
																 0x0E, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x04,		// 1
																 0x1F, 0x10, 0x08, 0x04, 0x02, 0x11, 0x0E,		// 2
																 0x0E, 0x11, 0x01, 0x06, 0x01, 0x11, 0x0E,		// 3
																 0x02, 0x02, 0x1F, 0x12, 0x0A, 0x06, 0x02,		// 4
																 0x0E, 0x11, 0x01, 0x1E, 0x10, 0x10, 0x1F,		// 5
																 0x0E, 0x11, 0x11, 0x1E, 0x10, 0x11, 0x0E,		// 6
																 0x04, 0x04, 0x04, 0x02, 0x02, 0x01, 0x1F,		// 7
																 0x0E, 0x11, 0x11, 0x0E, 0x11, 0x11, 0x0E,		// 8
																 0x0E, 0x11, 0x01, 0x0F, 0x11, 0x11, 0x0E,		// 9
																 0x11, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x0E,		// A
																 0x1E, 0x11, 0x11, 0x1E, 0x11, 0x11, 0x1E,		// B
																 0x0E, 0x11, 0x10, 0x10, 0x10, 0x11, 0x0E,		// C
																 0x1C, 0x12, 0x11, 0x11, 0x11, 0x12, 0x1C,		// D
																 0x0F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x0F,		// E
																 0x10, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x0F};		// F
																
unsigned char code Col_Select[]={0xFE, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF};
unsigned char buffer[2];

void main()
{
	while(1)
	{
		unsigned char i,j,k;
		for(j=0;j<=15;j++)
		{
			for(k=0;k<20;k++)
			{
				for(i=0;i<7;i++)
				{
					buffer[0] = Font5x7[j][i];
					buffer[1] = Col_Select[i];
					Xuat_Byte(buffer,2);
					Delay_ms(5);
				}
			}
		}
	}
}